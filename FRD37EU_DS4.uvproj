# Keil uVision project FRD37EU_DS4.uvproj, settings and files
target FRD37EU_DS4 (ARM-ADS)
  device: LPC1765 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: main_ngmm_release +hex
  BeforeMake: c:\cygwin\bin\perl.exe D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\scripts\pre-build 933
  AfterMake: D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\out\out.bat #H, NGMM
  c flags: OneElfS=1
  c define: CM800_DEI_BRAND=1 PLATFORM_933 LIB_DL_ENABLE=1
  c include: .\external\can.sdk.ds4\APP\features\falcon;external\can.sdk.ds4\APP\features\dei\lib.dei_core;external\can.sdk.ds4\APP\features\dei\lib.dei_rs;external\can.sdk.ds4\APP\features\dei\lib.dei_scpp;external\can.sdk.ds4\APP\features\dei\lib.dei_ss;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.per;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.sync;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.can.usr;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.dl;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.hazard;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.key_wrap;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.led.detect;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.light.format;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.nvfs.log;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.obd_can;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.pipe;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.process;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.sense_rs_can;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.timeout_q;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.tr;external\can.sdk.ds4\APP\features\falcon\core\lib.flc.tsk.rs;external\can.sdk.ds4\APP\features\general\lib.about;external\can.sdk.ds4\APP\features\general\lib.brand;external\can.sdk.ds4\APP\features\general\lib.display;external\can.sdk.ds4\APP\features\general\lib.feature;external\can.sdk.ds4\APP\features\ngmm\lib.ngmm_feature;external\can.sdk.ds4\APP\framework\lib.status_system;external\can.sdk.ds4\APP\framework\lib.system;external\can.sdk.ds4\APP\framework\lib.system_ui;external\can.sdk.ds4\APP\services\control\lib.cmd;external\can.sdk.ds4\APP\services\control\lib.ctl.dl;external\can.sdk.ds4\APP\services\control\lib.pts_ctl;external\can.sdk.ds4\APP\services\events\lib.evt;external\can.sdk.ds4\APP\services\events\lib.notify;external\can.sdk.ds4\APP\services\events\lib.sense.notify;external\can.sdk.ds4\APP\services\outputs\lib.led;external\can.sdk.ds4\APP\services\outputs\lib.out;external\can.sdk.ds4\APP\services\outputs\lib.out_fifo;external\can.sdk.ds4\APP\services\outputs\lib.out_q;external\can.sdk.ds4\APP\services\outputs\lib.siren;external\can.sdk.ds4\APP\services\queues\lib.exec;external\can.sdk.ds4\APP\services\queues\lib.fifo;external\can.sdk.ds4\APP\services\queues\lib.q;external\can.sdk.ds4\APP\services\queues\lib.reg.q;external\can.sdk.ds4\APP\services\sensors\lib.ecm_vtacho;external\can.sdk.ds4\APP\services\sensors\lib.sense_rs;external\can.sdk.ds4\APP\services\sensors\lib.sensor;external\can.sdk.ds4\APP\services\sensors\lib.sensor_proto;external\can.sdk.ds4\APP\services\sensors\lib.speed;external\can.sdk.ds4\APP\services\sensors\lib.tacho;external\can.sdk.ds4\APP\services\sensors\lib.temperature;external\can.sdk.ds4\APP\services\sensors\lib.voltage;external\can.sdk.ds4\APP\services\status\lib.bus.status;external\can.sdk.ds4\APP\services\status\lib.status;external\can.sdk.ds4\APP\services\status\lib.status.req;external\can.sdk.ds4\APP\services\timing\lib.sync_count;external\can.sdk.ds4\APP\services\timing\lib.timeout;external\can.sdk.ds4\APP\services\timing\lib.timeout.f;external\can.sdk.ds4\APP\services\trace\lib.dbgcli;external\can.sdk.ds4\APP\utilities\lib.bitfield;external\can.sdk.ds4\APP\utilities\lib.crc;external\can.sdk.ds4\APP\utilities\lib.eips;external\can.sdk.ds4\APP\utilities\lib.npc;external\can.sdk.ds4\APP\utilities\lib.prk;external\can.sdk.ds4\APP\utilities\lib.reg;external\can.sdk.ds4\APP\vehicle\diagnostics\com.ext.lib.obd_can;external\can.sdk.ds4\APP\vehicle\diagnostics\lib.vin;external\can.sdk.ds4\APP\vehicle\programming\lib.prg;external\can.sdk.ds4\APP\vehicle\programming\lib.prg_out;external\can.sdk.ds4\APP\vehicle\security\com.lib.dst;external\can.sdk.ds4\APP\vehicle\security\com.lib.dst_bus;external\can.sdk.ds4\APP\vehicle\security\com.lib.dstcrypt;external\can.sdk.ds4\APP\vehicle\security\com.lib.key;external\can.sdk.ds4\APP\vehicle\security\lib.fob.ctrl.dei;external\can.sdk.ds4\BSP\bootloader\lib.app.scatter.1766;external\can.sdk.ds4\BSP\mcu\device\lib.device;external\can.sdk.ds4\BSP\mcu\device\lib.hw_ver_code;external\can.sdk.ds4\BSP\mcu\device\lib.system.type;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.dei_led_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.dei_out_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.device.lpc1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.fob_ctrl_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.nvfs_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.os_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.os_1700.machine;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.prog_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.sys_1700;external\can.sdk.ds4\BSP\mcu\lpc1700\lib.wake_1700;external\can.sdk.ds4\BSP\peripherals\analog\com.lib.hw.dac;external\can.sdk.ds4\BSP\peripherals\analog\lib.adc;external\can.sdk.ds4\BSP\peripherals\analog\lib.dac;external\can.sdk.ds4\BSP\peripherals\can\com.ext.lib.can;external\can.sdk.ds4\BSP\peripherals\can\com.ext.lib.can.lut.sw;external\can.sdk.ds4\BSP\peripherals\gpio\lib.800_gpio_1700;external\can.sdk.ds4\BSP\peripherals\gpio\lib.gpio_pl;external\can.sdk.ds4\BSP\peripherals\gpio\lib.gpio_wake;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.fiq;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.irq.usr_1700;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.isr_1700;external\can.sdk.ds4\BSP\peripherals\interrupts\lib.vic;external\can.sdk.ds4\BSP\peripherals\serial\lib.sio;external\can.sdk.ds4\BSP\peripherals\serial\lib.sio_uart;external\can.sdk.ds4\BSP\peripherals\timers\lib.rtc;external\can.sdk.ds4\BSP\peripherals\timers\lib.tmr;external\can.sdk.ds4\BSP\peripherals\timers\lib.tmr.irq;external\can.sdk.ds4\BSP\peripherals\timers\lib.vrtc;external\can.sdk.ds4\BSP\peripherals\timers\lib.vrtc.f;external\can.sdk.ds4\BSP\peripherals\watchdog\lib.wdog;external\can.sdk.ds4\ENTRY\lib.main_1700;external\can.sdk.ds4\HAL\communication\can\com.ext.lib.can.v;external\can.sdk.ds4\HAL\communication\can\com.ext.lib.can.v.usr;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d.code\full;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d1_port;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d2_port;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d_switch;external\can.sdk.ds4\HAL\communication\d2d\lib.d2d_valet;external\can.sdk.ds4\HAL\communication\d2d\lib.intl_port;external\can.sdk.ds4\HAL\communication\rf\lib.keeloq;external\can.sdk.ds4\HAL\communication\rf\lib.rf;external\can.sdk.ds4\HAL\communication\rf\lib.rf_loop;external\can.sdk.ds4\HAL\communication\rf\lib.rftd;external\can.sdk.ds4\HAL\communication\rf\lib.rftd2;external\can.sdk.ds4\HAL\io\lib.idb;external\can.sdk.ds4\HAL\io\lib.ied;external\can.sdk.ds4\HAL\io\lib.led_usr;external\can.sdk.ds4\HAL\os\scheduler\lib.per_exec;external\can.sdk.ds4\HAL\os\scheduler\lib.reset;external\can.sdk.ds4\HAL\os\scheduler\lib.run_safe;external\can.sdk.ds4\HAL\power\wake\lib.wdog_v;external\can.sdk.ds4\HAL\security\lib.aes128;external\can.sdk.ds4\HAL\security\lib.aid_dhp;external\can.sdk.ds4\HAL\security\lib.secure.lock;external\can.sdk.ds4\HAL\storage\nvfs\lib.nvfs.usr;external\can.sdk.ds4\INC\cmall\core\inc.config.d2d;external\can.sdk.ds4\INC\cmall\core\inc.core_version;external\can.sdk.ds4\INC\cmall\core\inc.dummy;external\can.sdk.ds4\INC\common\core\inc.comm_core_version;VEHICLE_SPECIFIC\com.lib.detect;VEHICLE_SPECIFIC\com.lib.func;VEHICLE_SPECIFIC\com.lib.sense;VEHICLE_SPECIFIC\lib.fw.ds4\lib.fw;.\VEHICLE_SPECIFIC\lib.config.ds4\com.inc.config.fw;external\can.sdk.ds4\INC\cmall\core\inc.config_1700;.\external\can.sdk.ds4\INC\cmall\inc.config_fw;.\VEHICLE_SPECIFIC\lib.config.ds4\inc.config.d2d
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: external\can.sdk.ds4\BSP\bootloader\lib.app.scatter.1766\app.sct
  link misc: --diag_remark=6306,6238 --symdefs project.symdef
  group com.ext.lib.can
    external/can.sdk.ds4/BSP/peripherals/can/com.ext.lib.can/: can.c can.h
  group com.inc.config.fw
    ./VEHICLE_SPECIFIC/lib.config.ds4/com.inc.config.fw/: config_can.h config_dbg.h config_firmware.h config_gpio.h config_obd_can.h config_prog.h config_pts_ctl.h config_status.h
  group inc.config_fw
    ./VEHICLE_SPECIFIC/lib.config.ds4/inc.config_fw/: config_dei_feature.h config_ngmm_feature.h
  group lib.fw
    ./VEHICLE_SPECIFIC/lib.fw.ds4/lib.fw/: fw.h fw_dbg.c fw_init.c fw_init_reset.c fw_private.h
  group cm800_core
    external/can.sdk.ds4/BSP/peripherals/gpio/lib.800_gpio_1700/: 800_gpio_1700.c
    external/can.sdk.ds4/APP/features/general/lib.about/: about.c
    external/can.sdk.ds4/BSP/peripherals/analog/lib.adc/: adc.c
    external/can.sdk.ds4/APP/features/general/lib.brand/: brand.c
    external/can.sdk.ds4/ENTRY/lib.main_1700/: crt0.s main.c
    external/can.sdk.ds4/BSP/peripherals/analog/lib.dac/: dac.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.dei_led_1700/: dei_led_1700.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.dei_out_1700/: dei_out_1700.c
    external/can.sdk.ds4/APP/features/dei/lib.dei_rs/: dei_rs.c
    external/can.sdk.ds4/APP/features/dei/lib.dei_scpp/: dei_scpp.c
    external/can.sdk.ds4/APP/features/dei/lib.dei_ss/: dei_ss.c
    external/can.sdk.ds4/APP/features/general/lib.display/: display.c
    external/can.sdk.ds4/APP/services/sensors/lib.ecm_vtacho/: ecm_vtacho.c
    external/can.sdk.ds4/APP/services/events/lib.evt/: evt.c
    external/can.sdk.ds4/APP/features/general/lib.feature/: feature.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.fob_ctrl_1700/: fob_ctrl.c
    external/can.sdk.ds4/APP/vehicle/security/lib.fob.ctrl.dei/: fob_ctrl_dei.c
    external/can.sdk.ds4/HAL/communication/rf/lib.keeloq/: keeloq.c
    external/can.sdk.ds4/APP/services/outputs/lib.led/: led.c
    external/can.sdk.ds4/ENTRY/lib.ngmm_task_main/: ngmm_task_main.c
    external/can.sdk.ds4/APP/services/events/lib.notify/: notify.c
    external/can.sdk.ds4/APP/utilities/lib.npc/: npc.c
    external/can.sdk.ds4/APP/services/outputs/lib.out/: out.c
    external/can.sdk.ds4/APP/services/outputs/lib.out_fifo/: out_fifo.c
    external/can.sdk.ds4/APP/services/outputs/lib.out_q/: out_q.c
    external/can.sdk.ds4/APP/vehicle/programming/lib.prg/: prg.c
    external/can.sdk.ds4/APP/vehicle/programming/lib.prg_out/: prg_out.c
    external/can.sdk.ds4/APP/utilities/lib.prk/: prk.c
    external/can.sdk.ds4/BSP/peripherals/timers/lib.rtc/: rtc.c
    external/can.sdk.ds4/APP/services/sensors/lib.sense_rs/: sense_rs.c
    external/can.sdk.ds4/APP/services/sensors/lib.sensor/: sensor.c
    external/can.sdk.ds4/BSP/peripherals/serial/lib.sio/: sio.c
    external/can.sdk.ds4/BSP/peripherals/serial/lib.sio_uart/: sio_uart.c
    external/can.sdk.ds4/APP/services/outputs/lib.siren/: siren.c
    external/can.sdk.ds4/APP/framework/lib.status_system/: status_system.c
    external/can.sdk.ds4/APP/services/timing/lib.sync_count/: sync_count.c
    external/can.sdk.ds4/APP/framework/lib.system/: system.c
    external/can.sdk.ds4/APP/services/sensors/lib.tacho/: tacho.c
    external/can.sdk.ds4/APP/services/sensors/lib.temperature/: temperature.c
    external/can.sdk.ds4/BSP/peripherals/timers/lib.tmr.irq/: tmr_irq.c
    external/can.sdk.ds4/APP/services/sensors/lib.voltage/: voltage.c
    external/can.sdk.ds4/BSP/peripherals/timers/lib.vrtc/: vrtc.c
    external/can.sdk.ds4/BSP/peripherals/timers/lib.vrtc.f/: vrtc_f.c
    external/can.sdk.ds4/APP/services/sensors/lib.sensor_proto/: sensor_proto.c
    external/can.sdk.ds4/APP/features/ngmm/lib.ngmm_feature/: ngmm_feature.c
    external/can.sdk.ds4/APP/framework/lib.system_ui/: system_ui.c
    external/can.sdk.ds4/APP/services/sensors/lib.tach/: tach_update.c
    external/can.sdk.ds4/APP/services/sensors/lib.speed/: speed.c
  group com.common_core
    external/can.sdk.ds4/HAL/security/lib.aes128/: aes128.c
    external/can.sdk.ds4/HAL/security/lib.aid_dhp/: aid_dhp.c
    external/can.sdk.ds4/APP/utilities/lib.bitfield/: bitfield.c
    external/can.sdk.ds4/APP/services/status/lib.bus.status/: bus_status.c
    external/can.sdk.ds4/APP/services/control/lib.cmd/: cmd.c
    external/can.sdk.ds4/APP/utilities/lib.crc/: crc.c
    external/can.sdk.ds4/APP/services/control/lib.ctl.dl/: ctl_dl.c
    external/can.sdk.ds4/HAL/communication/d2d/lib.d2d1_port/: d2d1_port.c
    external/can.sdk.ds4/HAL/communication/d2d/lib.d2d2_port/: d2d2_port.c
    external/can.sdk.ds4/HAL/communication/d2d/lib.d2d_switch/: d2d_switch.c
    external/can.sdk.ds4/HAL/communication/d2d/lib.d2d_valet/: d2d_valet.c
    external/can.sdk.ds4/APP/services/queues/lib.exec/: exec.c
    external/can.sdk.ds4/APP/services/queues/lib.fifo/: fifo.c
    external/can.sdk.ds4/BSP/peripherals/interrupts/lib.fiq/: fiq.c
    external/can.sdk.ds4/BSP/peripherals/gpio/lib.gpio_pl/: gpio_pl.c
    external/can.sdk.ds4/BSP/peripherals/gpio/lib.gpio_wake/: gpio_wake.c
    external/can.sdk.ds4/HAL/io/lib.idb/: idb.c
    external/can.sdk.ds4/HAL/io/lib.ied/: ied.c
    external/can.sdk.ds4/HAL/communication/d2d/lib.intl_port/: intl_port.c
    external/can.sdk.ds4/BSP/peripherals/interrupts/lib.irq.usr_1700/: irq_usr_1700.c
    external/can.sdk.ds4/BSP/peripherals/interrupts/lib.isr_1700/: isr_1700.c
    external/can.sdk.ds4/HAL/io/lib.led_usr/: led_usr.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.nvfs_1700/: nvfs_1700.c
    external/can.sdk.ds4/HAL/storage/nvfs/lib.nvfs.usr/: nvfs_usr_vars.c
    external/can.sdk.ds4/HAL/os/scheduler/lib.per_exec/: per_exec.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.prog_1700/: prog.c
    external/can.sdk.ds4/APP/services/control/lib.pts_ctl/: pts_ctl.c
    external/can.sdk.ds4/APP/services/queues/lib.q/: q.c
    external/can.sdk.ds4/APP/utilities/lib.reg/: reg.c
    external/can.sdk.ds4/APP/services/queues/lib.reg.q/: reg_q.c
    external/can.sdk.ds4/HAL/os/scheduler/lib.reset/: reset.c
    external/can.sdk.ds4/HAL/communication/rf/lib.rf/: rf.c
    external/can.sdk.ds4/HAL/communication/rf/lib.rftd/: rftd.c
    external/can.sdk.ds4/HAL/communication/rf/lib.rftd2/: rftd2.c
    external/can.sdk.ds4/HAL/os/scheduler/lib.run_safe/: run_safe.c
    external/can.sdk.ds4/HAL/security/lib.secure.lock/: secure_lock.c
    external/can.sdk.ds4/APP/services/events/lib.sense.notify/: sense_notify.c
    external/can.sdk.ds4/APP/services/status/lib.status/: status.c
    external/can.sdk.ds4/APP/services/status/lib.status.req/: status_req.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.sys_1700/: sys_1700.c
    external/can.sdk.ds4/BSP/mcu/device/lib.system.type/: system_type.c
    external/can.sdk.ds4/APP/services/timing/lib.timeout/: timeout.c
    external/can.sdk.ds4/APP/services/timing/lib.timeout.f/: timeout_f.c
    external/can.sdk.ds4/BSP/peripherals/timers/lib.tmr/: tmr.c
    external/can.sdk.ds4/APP/vehicle/diagnostics/lib.vin/: vin.c
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.wake_1700/: wake_1700.c
    external/can.sdk.ds4/BSP/peripherals/watchdog/lib.wdog/: wdog.c
    external/can.sdk.ds4/HAL/power/wake/lib.wdog_v/: wdog_v.c
    external/can.sdk.ds4/APP/services/trace/lib.dbgcli/: dbgcli.c
  group com.ext.os
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.os_1700/: os_1700.c
  group com.ext.os.machine
    external/can.sdk.ds4/BSP/mcu/lpc1700/lib.os_1700.machine/: os.machine_a.s os.machine_c.c
  group falcon_core
    external/can.sdk.ds4/APP/features/falcon/: falcon.c core_framework.h
  group lib.led_usr
    external/can.sdk.ds4/HAL/io/lib.led_usr/: led_usr.h led_usr_private.h
  group com.lib.detect
    VEHICLE_SPECIFIC/com.lib.detect/: detect.h detect_can_search.c detect_car_search.c detect_ign_search.c detect_init_nvfs.c detect_pgm.c detect_private.h detect_vars.c detect_vin_search.c
  group com.lib.func
    VEHICLE_SPECIFIC/com.lib.func/: func.h func_arm.c func_cfg.h func_cmd.c func_cmd_init.c func_disarm.c func_domelight.c func_hazard_ctrl.c func_init.c func_light.c func_lock.c func_oem.c func_prc_init.c func_private.h func_rs.c func_rs_pts_callback.c func_trunk_release.c func_unlock_all.c func_vars.c
    ./VEHICLE_SPECIFIC/com.lib.func/: func_can_wake.c func_front_wrd.c func_gas_cap.c func_rear_wrd.c func_tester_lock_unlock.c func_wru.c
  group com.lib.sense
    VEHICLE_SPECIFIC/com.lib.sense/: sense.h sense_brake.c sense_doors.c sense_handbrake.c sense_hazard.c sense_hood.c sense_ignition.c sense_init.c sense_private.h sense_rke.c sense_rpm.c sense_skd.c sense_speed.c sense_trunk.c sense_vars.c sense_windows_pos.c
    ./VEHICLE_SPECIFIC/com.lib.sense/: sense_index_331.c sense_index_332.c sense_index_446.c sense_manual_box.c
  group lib.vic
    external/can.sdk.ds4/BSP/peripherals/interrupts/lib.vic/: vic.h vic_set_vector.c
