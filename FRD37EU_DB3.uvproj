# Keil uVision project FRD37EU_DB3.uvproj, settings and files
target FRD37EU_DB3 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: main_db3_release +hex
  BeforeMake: c:\cygwin\bin\perl.exe D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\scripts\pre-build.pl 403
  BeforeMake: powershell.exe -ExecutionPolicy Bypass -File D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\scripts\check_noncore_core_boundary.ps1
  AfterMake: D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\out\out.bat #H,DBALL3
  AfterMake: powershell.exe -ExecutionPolicy Bypass -File D:\ADI\DB3\Based_on_latest_core\FRD37EU_NEW\can.fw.frd37eu\build\scripts\split_db3_hex_images.ps1 -InputHex .\build\db3_build\main_db3_release.hex -OutputDir .\build\db3_build
  c flags: Optim=4 OneElfS=1
  c include: ./VEHICLE_SPECIFIC/lib.config.db3/com.inc.config.fw;./VEHICLE_SPECIFIC/com.lib.detect;./VEHICLE_SPECIFIC/com.lib.func;./VEHICLE_SPECIFIC/com.lib.sense;./external/can.sdk.db3/APP/features/dball3/lib.about;./external/can.sdk.db3/APP/features/dball3/lib.display;./external/can.sdk.db3/APP/features/dball3/lib.rsr;./external/can.sdk.db3/APP/features/dball3/lib.rsr_feature;./external/can.sdk.db3/APP/features/dball3/lib.rxt;./external/can.sdk.db3/APP/features/dball3/lib.w2w;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.per;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.sync;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.can.usr;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.dl;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.hazard;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.key_wrap;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.led.detect;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.light.format;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.nvfs.log;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.obd_can;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.pipe;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.process;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.sense_rs_can;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.timeout_q;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.tr;./external/can.sdk.db3/APP/features/falcon/core/lib.flc.tsk.rs;./external/can.sdk.db3/APP/framework/lib.core;./external/can.sdk.db3/APP/framework/lib.status_system;./external/can.sdk.db3/APP/services/control/lib.cmd;./external/can.sdk.db3/APP/services/control/lib.ctl.dl;./external/can.sdk.db3/APP/services/control/lib.pts_ctl;./external/can.sdk.db3/APP/services/events/lib.sense.notify;./external/can.sdk.db3/APP/services/outputs/lib.led;./external/can.sdk.db3/APP/services/outputs/lib.out;./external/can.sdk.db3/APP/services/outputs/lib.out_fifo;./external/can.sdk.db3/APP/services/outputs/lib.out_q;./external/can.sdk.db3/APP/services/queues/lib.exec;./external/can.sdk.db3/APP/services/queues/lib.fifo;./external/can.sdk.db3/APP/services/queues/lib.q;./external/can.sdk.db3/APP/services/queues/lib.reg.q;./external/can.sdk.db3/APP/services/sensors/lib.tach;./external/can.sdk.db3/APP/services/status/lib.bus.status;./external/can.sdk.db3/APP/services/status/lib.status;./external/can.sdk.db3/APP/services/status/lib.status.req;./external/can.sdk.db3/APP/services/timing/lib.timeout;./external/can.sdk.db3/APP/services/timing/lib.timeout.f;./external/can.sdk.db3/APP/services/trace/lib.dbg;./external/can.sdk.db3/APP/services/trace/lib.trace;./external/can.sdk.db3/APP/utilities/lib.bitfield;./external/can.sdk.db3/APP/utilities/lib.crc;./external/can.sdk.db3/APP/utilities/lib.eips;./external/can.sdk.db3/APP/utilities/lib.reg;./external/can.sdk.db3/APP/vehicle/diagnostics/com.ext.lib.obd_can;./external/can.sdk.db3/APP/vehicle/diagnostics/lib.vin;./external/can.sdk.db3/APP/vehicle/programming/lib.prog_1700;./external/can.sdk.db3/APP/vehicle/security/com.lib.dst;./external/can.sdk.db3/APP/vehicle/security/com.lib.dst_bus;./external/can.sdk.db3/APP/vehicle/security/com.lib.dstcrypt;./external/can.sdk.db3/APP/vehicle/security/com.lib.key;./external/can.sdk.db3/BSP/bootloader/lib.app.scatter.1766;./external/can.sdk.db3/BSP/mcu/device/lib.device;./external/can.sdk.db3/BSP/mcu/device/lib.hw_ver_code;./external/can.sdk.db3/BSP/mcu/device/lib.system.type;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.device.lpc1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.gpio_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.nvfs_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700.machine;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.sys_1700;./external/can.sdk.db3/BSP/mcu/lpc1700/lib.wake_1700;./external/can.sdk.db3/BSP/peripherals/analog/lib.dac;./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.adc;./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.dac;./external/can.sdk.db3/BSP/peripherals/can/com.ext.lib.can;./external/can.sdk.db3/BSP/peripherals/can/com.ext.lib.can.lut.sw;./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_pl;./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_wake;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.fiq;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.irq.usr_1700;./external/can.sdk.db3/BSP/peripherals/interrupts/lib.isr_1700;./external/can.sdk.db3/BSP/peripherals/serial/lib.sio;./external/can.sdk.db3/BSP/peripherals/serial/lib.sio_uart;./external/can.sdk.db3/BSP/peripherals/timers/lib.tmr;./external/can.sdk.db3/BSP/peripherals/watchdog/lib.wdog;./external/can.sdk.db3/ENTRY/lib.main_1700;./external/can.sdk.db3/ENTRY/lib.task_main;./external/can.sdk.db3/HAL/communication/can/com.ext.lib.can.v;./external/can.sdk.db3/HAL/communication/can/com.ext.lib.can.v.usr;./external/can.sdk.db3/HAL/communication/d2d/lib.d2d;./external/can.sdk.db3/HAL/communication/d2d/lib.d2d.code/full;./external/can.sdk.db3/HAL/communication/d2di/lib.d2di;./external/can.sdk.db3/HAL/communication/d2di/lib.d2di_uart;./external/can.sdk.db3/HAL/communication/rf/lib.rf;./external/can.sdk.db3/HAL/communication/rf/lib.rf_loop;./external/can.sdk.db3/HAL/communication/rf/lib.rftd;./external/can.sdk.db3/HAL/communication/rf/lib.rftd2;./external/can.sdk.db3/HAL/io/lib.idb;./external/can.sdk.db3/HAL/io/lib.ied;./external/can.sdk.db3/HAL/io/lib.led_usr;./external/can.sdk.db3/HAL/os/scheduler/lib.per_exec;./external/can.sdk.db3/HAL/os/scheduler/lib.reset;./external/can.sdk.db3/HAL/os/scheduler/lib.run_safe;./external/can.sdk.db3/HAL/power/wake/lib.wdog_v;./external/can.sdk.db3/HAL/security/lib.secure.lock;./external/can.sdk.db3/HAL/storage/nvfs/lib.nvfs.usr;./external/can.sdk.db3/INC/dball/core/inc.config_1700;./external/can.sdk.db3/INC/falcon/core/db3_dummy;.\VEHICLE_SPECIFIC\lib.config.db3\inc.config.d2d;.\VEHICLE_SPECIFIC\lib.fw.db3\lib.fw;.\external\can.sdk.db3\APP\features\falcon;.\external\can.sdk.db3\BSP\peripherals\interrupts\lib.vic;.\external\can.sdk.db3\INC\dball\inc.config.fw;.\external\can.sdk.db3\CONTRACT_SDK_DB3;.\external\Core_Contract_SDK_DB3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\external\can.sdk.db3\BSP\bootloader\lib.app.scatter.1766\app.sct
  link misc: --diag_remark=6306,6238 --symdefs project.symdef
  group com.ext.lib.can
    ./external/can.sdk.db3/BSP/peripherals/can/com.ext.lib.can/: can.c can.h
  group inc.config.fw
    ./external/can.sdk.db3/INC/dball/inc.config.fw/: config_dball.h
  group inc.config.d2d
    ./external/can.sdk.db3/INC/dball/core/inc.config.template/inc.config.d2d/: config_d2d.h
  group lib.fw.db3
    ./VEHICLE_SPECIFIC/lib.fw.db3/lib.fw/: fw.h fw_init.c fw_init_reset.c
  group dball3_core
    ./external/can.sdk.db3/APP/features/dball3/lib.about/: about.c about.h
    ./external/can.sdk.db3/HAL/communication/d2di/lib.d2di/: d2di.c d2di.h
    ./external/can.sdk.db3/HAL/communication/d2di/lib.d2di_uart/: d2di_uart.c d2di_uart.h
    ./external/can.sdk.db3/BSP/peripherals/analog/lib.dac/: dac.c dac.h
    ./external/can.sdk.db3/APP/features/dball3/lib.display/: display.c display.h
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.gpio_1700/: gpio.h gpio_init.c
    ./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.adc/: hw_adc.c hw_adc.h
    ./external/can.sdk.db3/BSP/peripherals/analog/lib.hw.dac/: hw_dac.c hw_dac.h
    ./external/can.sdk.db3/ENTRY/lib.main_1700/: crt0.s
    ./external/can.sdk.db3/APP/services/sensors/lib.tach/: tach.c tach.h
    ./external/can.sdk.db3/APP/features/dball3/lib.w2w/: w2w.c w2w.h
    ./external/can.sdk.db3/APP/framework/lib.core/: core.c core.h
    ./external/can.sdk.db3/APP/services/trace/lib.dbg/: dbg.c
    ./external/can.sdk.db3/APP/features/dball3/lib.rsr/: rsr.c rsr.h
    ./external/can.sdk.db3/APP/features/dball3/lib.rsr_feature/: rsr_feature.c rsr_feature.h
  group com.common_core
    ./external/can.sdk.db3/APP/utilities/lib.bitfield/: bitfield.c bitfield.h
    ./external/can.sdk.db3/APP/services/status/lib.bus.status/: bus_status.c bus_status.h
    ./external/can.sdk.db3/APP/services/control/lib.cmd/: cmd.c cmd.h
    ./external/can.sdk.db3/APP/utilities/lib.crc/: crc.c crc.h
    ./external/can.sdk.db3/APP/services/control/lib.ctl.dl/: ctl_dl.c ctl_dl.h
    ./external/can.sdk.db3/HAL/communication/d2d/lib.d2d/: d2d.c d2d.h
    ./external/can.sdk.db3/APP/services/queues/lib.exec/: exec.c exec.h
    ./external/can.sdk.db3/APP/services/queues/lib.fifo/: fifo.c fifo.h
    ./external/can.sdk.db3/BSP/peripherals/interrupts/lib.fiq/: fiq.c fiq.h
    ./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_wake/: gpio_wake.c gpio_wake.h
    ./external/can.sdk.db3/HAL/io/lib.idb/: idb.c idb.h
    ./external/can.sdk.db3/HAL/io/lib.ied/: ied.c ied.h
    ./external/can.sdk.db3/BSP/peripherals/interrupts/lib.irq.usr_1700/: irq_user.c irq_user.h
    ./external/can.sdk.db3/BSP/peripherals/interrupts/lib.isr_1700/: isr.c isr.h
    ./external/can.sdk.db3/HAL/storage/nvfs/lib.nvfs.usr/: nvfs_usr.c nvfs_usr.h
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.nvfs_1700/: nvfs.c nvfs.h
    ./external/can.sdk.db3/HAL/os/scheduler/lib.per_exec/: per_exec.c per_exec.h
    ./external/can.sdk.db3/APP/vehicle/programming/lib.prog/: prog.c prog.h
    ./external/can.sdk.db3/APP/services/queues/lib.q/: q.c q.h
    ./external/can.sdk.db3/APP/utilities/lib.reg/: reg.c reg.h
    ./external/can.sdk.db3/APP/services/queues/lib.reg.q/: reg_q.c reg_q.h
    ./external/can.sdk.db3/HAL/os/scheduler/lib.reset/: reset.c reset.h
    ./external/can.sdk.db3/HAL/communication/rf/lib.rf/: rf.c rf.h
    ./external/can.sdk.db3/HAL/communication/rf/lib.rf_loop/: rf_loop.c rf_loop.h
    ./external/can.sdk.db3/HAL/communication/rf/lib.rftd/: rftd.c rftd.h
    ./external/can.sdk.db3/HAL/communication/rf/lib.rftd2/: rftd2.c rftd2.h
    ./external/can.sdk.db3/HAL/security/lib.secure.lock/: secure_lock.c secure_lock.h
    ./external/can.sdk.db3/APP/services/events/lib.sense.notify/: sense_notify.c sense_notify.h
    ./external/can.sdk.db3/APP/services/status/lib.status/: status.c status.h
    ./external/can.sdk.db3/APP/services/status/lib.status.req/: status_req.c status_req.h
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.sys_1700/: sys.c sys.h
    ./external/can.sdk.db3/BSP/mcu/device/lib.system.type/: system_type.c system_type.h
    ./external/can.sdk.db3/APP/services/timing/lib.timeout/: timeout.c timeout.h
    ./external/can.sdk.db3/APP/services/timing/lib.timeout.f/: timeout_f.c timeout_f.h
    ./external/can.sdk.db3/BSP/peripherals/timers/lib.tmr/: tmr.c tmr.h
    ./external/can.sdk.db3/APP/vehicle/diagnostics/lib.vin/: vin.c vin.h
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.wake_1700/: wake.c wake.h
    ./external/can.sdk.db3/BSP/peripherals/watchdog/lib.wdog/: wdog.c wdog.h
    ./external/can.sdk.db3/HAL/power/wake/lib.wdog_v/: wdog_v.c wdog_v.h
    ./external/can.sdk.db3/BSP/peripherals/gpio/lib.gpio_pl/: gpio_pl.c
    ./external/can.sdk.db3/APP/services/control/lib.pts_ctl/: pts_ctl.c pts_ctl.h
    ./external/can.sdk.db3/HAL/os/scheduler/lib.run_safe/: run_safe.c run_safe.h
  group com.ext.os
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700/: os_elig.c os_evt.c os_flg.c os_gte.c os_irq.c os_kern.c os_mbx.c os_msg.c os_pip.c os_pte.c os_queue.c os_res.c os_stk.c os_swi.c os_tfr.c os_timeout.c os_timer.c os_tsk.c os_vars.c
  group com.ext.os.machine
    ./external/can.sdk.db3/BSP/mcu/lpc1700/lib.os_1700.machine/: os.machine_c.c os.machine_a.s
  group falcon_core
    ./external/can.sdk.db3/APP/features/falcon/: falcon.c core_framework.h
  group lib.led_usr
    ./external/can.sdk.db3/HAL/io/lib.led_usr/: led_usr.c led_usr.h led_usr_private.h
  group com.lib.detect
    ./VEHICLE_SPECIFIC/com.lib.detect/: detect.h detect_can_search.c detect_car_search.c detect_ign_search.c detect_init.c detect_init_nvfs.c detect_pgm.c detect_private.h detect_vars.c detect_vin_search.c
  group com.lib.func
    ./VEHICLE_SPECIFIC/com.lib.func/: func.h func_arm.c func_cfg.h func_cmd.c func_cmd_init.c func_disarm.c func_domelight.c func_hazard_ctrl.c func_init.c func_light.c func_lock.c func_oem.c func_prc_init.c func_private.h func_rs.c func_rs_pts_callback.c func_trunk_release.c func_unlock_all.c func_vars.c func_tester_lock_unlock.c
  group com.lib.sense
    ./VEHICLE_SPECIFIC/com.lib.sense/: sense.h sense_brake.c sense_doors.c sense_handbrake.c sense_hazard.c sense_hood.c sense_ignition.c sense_index_331.c sense_index_332.c sense_index_446.c sense_init.c sense_manual_box.c sense_private.h sense_rke.c sense_rpm.c sense_skd.c sense_speed.c sense_trunk.c sense_vars.c sense_windows_pos.c
  group lib.vic
    ./external/can.sdk.db3/BSP/peripherals/interrupts/lib.vic/: vic.h vic_set_vector.c
  group com.gpio.iface
    ./external/can.sdk.db3/APP/services/gpio_iface/: gpio_iface.h gpio_iface_clutch.c gpio_iface_doors.c gpio_iface_handbrake.c gpio_iface_lights.c gpio_iface_private.c gpio_iface_private.h gpio_iface_pts_1.c gpio_iface_pts_2.c gpio_iface_rap.c gpio_iface_rf_loop.c gpio_iface_trunk.c
  group com.Core_Contract_SDK_DB3
    ./external/Core_Contract_SDK_DB3/: core_contract_db3_can_config.c core_contract_db3_can_config.h core_contract_db3_dbg_config.c core_contract_db3_dbg_config.h core_contract_db3_firmware_config.c core_contract_db3_firmware_config.h core_contract_db3_init.c core_contract_db3_init.h core_contract_db3_integration_example.h core_contract_db3_obd_can_config.h core_contract_db3_pts_ctl_config.c core_contract_db3_pts_ctl_config.h core_contract_db3_status_config.c core_contract_db3_status_config.h core_contract_db3_gpio_config.c core_contract_db3_gpio_config.h core_contract_db3_obd_can_config.c core_contract_db3_nvfs_entry_name.c core_contract_db3_nvfs_entry_name.h core_contract_db3_prog_config.c core_contract_db3_prog_config.h
